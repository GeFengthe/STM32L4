# Keil uVision project IOT-HAL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IOT-HAL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: .\libraries;.\libraries\Inc;.\libraries\Inc\Legacy;.\BSP\inc;.\System\delay;.\System\sys;.\System\usart;.\User;.\APP\inc;.\FreeRTOS\port\include;.\FreeRTOS\port\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group STARTUP
    ./libraries/: startup_stm32l475xx.s
  group CMSIS
    ./libraries/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h system_stm32l4xx.c
  group FWlibr
    ./libraries/Src/: stm32l4xx_hal_cortex.c stm32l4xx_hal_comp.c stm32l4xx_hal_can.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dsi.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_firewall.c stm32l4xx_hal_exti.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_lptim.c stm32l4xx_hal_lcd.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_irda.c stm32l4xx_hal_ospi.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_rcc.c stm32l4xx_hal_qspi.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_tsc.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group User
    ./User/: main.c FreeRTOSConfig.h stm32l4xx_it.c
  group BSP
    ./BSP/src/: esp8266.c lcd.c spi.c timer.c
  group APP
    ./APP/src/: mqtt.c aht10.c key.c motor.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM4F/: port.c

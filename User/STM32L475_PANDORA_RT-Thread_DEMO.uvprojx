# Keil uVision project STM32L475_PANDORA_RT-Thread_DEMO.uvprojx, settings and files
target STM32L475_PANDORA_RT-Thread_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L475_PANDORA_RT-Thread_DEMO
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L475xx
  c include: ..\USER;..\CMSIS;..\HALLIB\Inc\Legacy;..\HALLIB\Inc;..\RT-Thread\bsp;..\RT-Thread\device_drivers\inc;..\RT-Thread\device_drivers;..\RT-Thread\components\finsh;..\RT-Thread\include\libc;..\RT-Thread\include;..\BSP\led
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c delay.c
  group CMSIS
    ../CMSIS/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c
  group BSP
    ../BSP/led/: led.c
  group RT-Thread_bsp
    ../RT-Thread/bsp/: board.c drv_usart.c
  group RT-Thread_finsh
    ../RT-Thread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT-Thread_device_drviers
    ../RT-Thread/device_drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../RT-Thread/device_drivers/: serial.c
  group RT-Thread_libcpu
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group RT-Thread_kernel
    ../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
